# IAR project watch.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 1000
  General.GHeapSize2: 500
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: AUTOSTART_ENABLE=1; HAVE_BLE=1; AMX_ANSIONLY=1; BYTE_ORDER=LITTLE_ENDIAN; PAWN_CELL_SIZE=16; HAVE_ALLOCA_H=0; AMX_NATIVETABLE=window_natives
  ICC430.CCDiagSuppress: Pa050
  ICC430.newCCIncludePaths: ..\core; ..\cpu\msp430; ..\platform\iwatch; ..\platform\iwatch\btstack; ..\platform\iwatch\btstack\src; ..\imports\openobex; ..\platform\iwatch\btstack\ble; ..\platform\iwatch\btstack\; ..\platform\iwatch\btstack\chipset-cc256x; ..\platform\iwatch\btstack\include
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438A.xcl
  XLINK.XlinkStackSize: 1
configuration Retail (MSP430)
  as the first configuration, except:
  General.GStackSize2: 2048
  General.GHeapSize2: 3600
  ICC430.newCCIncludePaths: ..\core; ..\cpu\msp430; ..\ant; ..; ..\btstack; ..\platform\iwatch; ..\platform\iwatch\btstack; ..\btstack\src; ..\btstack\ble; ..\btstack\; ..\btstack\chipset-cc256x; ..\btstack\include
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  XLINK.XclFile: iwatch-lnk430F5438A.xcl
  group (top)
    ../pawnscript/: amx.c amxcons.c amxstring.c amxwindow.c
  group ant
    ../platform/iwatch/ant/: ant_timer.c main_hrm.c serial.c
    ../ant/: antinterface.c cbsc_rx.c data.c hrm_rx.c
  group app
    ../watch/: analog-watch.c btconfig.c calendar.c configtime.c controller.c controls.c cordic.c countdown.c digit-watch.c host.c menu.c names.c notification.c phone.c selftest.c siri.c sportsdata.c sportselect.c sportswatch.c sportwait.c status.c stopwatch.c symbols.c test.c today.c window.c worldclock.c
    ../gesture/: gesture.c
  group btstack
    ../platform/iwatch/btstack/: ble_handler.c ble_peripheral.c bluetooth.c codec.c config.h deviceid.c hal.c hal_compat.c hal_uart_dma.c run_loop.c sdp_client.c spp.c stlv.c stlv_client.c stlv_handler.c stlv_server.c stlv_transport.c
  group btstack/ble
    ../btstack/ble/: att.c att_server.c central_device_db_dummy.c central_device_db_memory.c l2cap_le.c sm.c sm_minimal.c
  group btstack/cc2564
    ../btstack/chipset-cc256x/: bluetooth_init_cc2564_2.10.c bt_control_cc256x.c
  group btstack/core
    ../btstack/src/: avctp.c avrcp.c btstack_memory.c hci.c hci_cmds.c hci_dump.c hci_transport_h4_ehcill_dma.c hfp.c l2cap.c l2cap_signaling.c linked_list.c mas.c memory_pool.c mns.c obex.c remote_device_db_memory.c rfcomm.c sdp.c sdp_util.c utils.c
  group core/cfs
    ../core/cfs/: cfs-coffee.c cfs-coffee.h cfs.h
  group core/lib
    ../core/lib/: list.c print-stats.c
  group core/net/rime
    ../core/net/rime/: rimeaddr.c rimestats.c
  group core/sys
    ../core/sys/: autostart.c ctimer.c energest.c etimer.c process.c procinit.c rtimer.c stimer.c timer.c
  group grlib
    ../grlib/: charmap.c circle.c context.c grlib.h image.c line.c rectangle.c string.c triagle.c
    ../platform/iwatch/: Template_Driver.c Template_Driver.h
  group grlib/fonts
    ../grlib/fonts/: fontbaby12.c fontbaby16.c fontdigit44.c fontdigit44b.c fontdigit52b.c fontdigit56.c fonticon16.c fonticon48.c fontnova12b.c fontnova13.c fontnova16.c fontnova16b.c fontnova28.c fontnova28b.c fontnova38.c fontnova38b.c fontnova50b.c fontred13.c fontunicode.c logoimg.c
  group mpl
    ../platform/iwatch/mpl/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c
  group pedometer
    ../pedometer/: pedometer.c pedometer.h pedometer_dist.c sleepalgo.r43
  group platform
    ../platform/iwatch/: backlight.c battery.c board.h button.c clock.c contiki-exp5438-main.c flash.c i2c.c isr.c msp430.c platform-conf.h printf.c progam.c rtc.c rtimer-arch.c spiflash.c system.c uart1-putchar.c watchdog.c
